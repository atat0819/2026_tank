# Keil uVision project tank_gimbal.uvprojx, settings and files
target tank_gimbal (6210000::V6.21::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: tank_gimbal +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../communication_between_boards;../feeder_fsm;../RtosTask;../user/core;../YAW_Auto_Controller-main
  asm include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c iwdg.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Alg
    ../user/core/Alg/ADRC/: adrc.cpp adrc.hpp AdrcBase.hpp
    ../user/core/Alg/Feedforward/: Feedforward.cpp Feedforward.hpp
    ../user/core/Alg/Filter/: Filter.cpp Filter.hpp
    ../user/core/Alg/fire_control/: fire_control.cpp fire_control.hpp friction_shot_detector.cpp friction_shot_detector.hpp single_shot_heat_limiter.cpp single_shot_heat_limiter.hpp
    ../user/core/Alg/FSM/: alg_fsm.cpp alg_fsm.hpp
    ../user/core/Alg/PID/: pid.cpp pid.hpp
  group Bsp
    ../user/core/BSP/Common/StateWatch/: state_watch.cpp state_watch.hpp buzzer_manager.cpp buzzer_manager.hpp
    ../user/core/BSP/IMU/: HI12_imu.hpp HI12Base.hpp
    ../user/core/BSP/Motor/: MotorBase.hpp
    ../user/core/BSP/buzzer/: buzzer.hpp
    ../user/core/BSP/Motor/Dji/: DjiMotor.hpp
    ../user/core/BSP/Motor/DM/: DmMotor.hpp
    ../user/core/BSP/Motor/LK/: Lk_motor.hpp
    ../user/core/BSP/RemoteControl/: DT7.cpp DT7.hpp
    ../user/core/BSP/version/: vision_communication.cpp vision_communication.hpp
  group HAL
    ../user/core/HAL/FDCAN/impl/: fdcan_bus_impl.cpp fdcan_bus_impl.hpp fdcan_device_impl.cpp fdcan_device_impl.hpp
    ../user/core/HAL/FDCAN/interface/: fdcan_bus.cpp fdcan_bus.hpp fdcan_device.cpp fdcan_device.hpp
    ../user/core/HAL/FDCAN/: fdcan_hal.hpp
    ../user/core/HAL/UART/impl/: uart_bus_impl.cpp uart_bus_impl.hpp uart_device_impl.cpp uart_device_impl.hpp
    ../user/core/HAL/UART/interface/: uart_bus.cpp uart_bus.hpp uart_device.hpp
    ../user/core/HAL/UART/: uart_hal.hpp
  group YawAutoController
    ../YAW_Auto_Controller-main/: yaw_auto_lqr_eso_controller.c
  group RtosTask
    ../RtosTask/: can_send_task.cpp can_send_task.hpp gimbal_task.cpp gimbal_task.hpp gantry_task.cpp gantry_task.hpp remote_control_task.cpp remote_control_task.hpp
  group boards_communication
    ../communication_between_boards/: boards_communication_uart_485.cpp boards_communication_uart_485.hpp HI14.cpp HI14.hpp input_dispatcher.cpp input_dispatcher.hpp gimbal_to_arm.cpp gimbal_to_arm.hpp
  group feeder_fsm
    ../feeder_fsm/: gantry_fsm.cpp gantry_fsm.hpp feeder_fsm.cpp feeder_fsm.hpp friction_fsm.cpp friction_fsm.hpp gimbal_fsm.cpp gimbal_fsm.hpp imu_feedback_fsm.hpp motor_recovery_fsm.hpp
software components: CMSIS:CORE 5.6.0
